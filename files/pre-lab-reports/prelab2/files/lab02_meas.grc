options:
  parameters:
    author: SDR Lab
    comment: ADALM-PLUTO receive-only preparation. 800 MHz is a prelab assumption. Hardware not tested.
    description: ADALM-PLUTO with IIO source; manual gain, AGC off; assigned team gain not announced
    generate_options: qt_gui
    id: lab02_meas
    output_language: python
    title: Lab02 - ADALM-PLUTO receive-only measurements
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: Initial gain 0 dB is a starting setting, not the assigned group gain.
    label: Manual RF gain (dB); AGC off
    value: '0'
    start: '0'
    stop: '73'
    step: '1'
  states: {}
- name: f1
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: f2
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: f_noise
  id: variable
  parameters:
    value: '-500e3'
  states: {}
- name: bw_noise
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: bw_tone
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: noise_band
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccf
    decim: '4'
    taps: firdes.low_pass(1, samp_rate, bw_noise/2, bw_noise/4)
    center_freq: f_noise
    samp_rate: samp_rate
  states: {}
- name: noise_rms
  id: blocks_rms_xx
  parameters:
    type: complex
    alpha: '2e-5'
  states: {}
- name: noise_db
  id: blocks_nlog10_ff
  parameters:
    n: '20'
    k: '0'
  states: {}
- name: noise_num
  id: qtgui_number_sink
  parameters:
    name: '"Noise power in the 400 kHz band (dBFS)"'
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '-120'
    max: '0'
    unit1: dBFS
  states: {}
- name: tone_num
  id: qtgui_number_sink
  parameters:
    name: '"Tone meters (10 kHz each)"'
    type: float
    graph_type: qtgui.NUM_GRAPH_NONE
    nconnections: '4'
    min: '-140'
    max: '0'
    label1: '"f1 (dBFS)"'
    label2: '"f2 (dBFS)"'
    label3: '"2 f1 - f2 (dBFS)"'
    label4: '"2 f2 - f1 (dBFS)"'
  states: {}
- name: t1_band
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccf
    decim: '64'
    taps: firdes.low_pass(1, samp_rate, bw_tone/2, bw_tone/2)
    center_freq: f1
    samp_rate: samp_rate
  states: {}
- name: t1_rms
  id: blocks_rms_xx
  parameters:
    type: complex
    alpha: '1e-3'
  states: {}
- name: t1_db
  id: blocks_nlog10_ff
  parameters:
    n: '20'
    k: '0'
  states: {}
- name: t2_band
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccf
    decim: '64'
    taps: firdes.low_pass(1, samp_rate, bw_tone/2, bw_tone/2)
    center_freq: f2
    samp_rate: samp_rate
  states: {}
- name: t2_rms
  id: blocks_rms_xx
  parameters:
    type: complex
    alpha: '1e-3'
  states: {}
- name: t2_db
  id: blocks_nlog10_ff
  parameters:
    n: '20'
    k: '0'
  states: {}
- name: im_lo_band
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccf
    decim: '64'
    taps: firdes.low_pass(1, samp_rate, bw_tone/2, bw_tone/2)
    center_freq: 2*f1 - f2
    samp_rate: samp_rate
  states: {}
- name: im_lo_rms
  id: blocks_rms_xx
  parameters:
    type: complex
    alpha: '1e-3'
  states: {}
- name: im_lo_db
  id: blocks_nlog10_ff
  parameters:
    n: '20'
    k: '0'
  states: {}
- name: im_hi_band
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccf
    decim: '64'
    taps: firdes.low_pass(1, samp_rate, bw_tone/2, bw_tone/2)
    center_freq: 2*f2 - f1
    samp_rate: samp_rate
  states: {}
- name: im_hi_rms
  id: blocks_rms_xx
  parameters:
    type: complex
    alpha: '1e-3'
  states: {}
- name: im_hi_db
  id: blocks_nlog10_ff
  parameters:
    n: '20'
    k: '0'
  states: {}
- name: total_rms
  id: blocks_rms_xx
  parameters:
    type: complex
    alpha: '1e-4'
  states: {}
- name: total_log
  id: blocks_nlog10_ff
  parameters:
    n: '20'
    k: '0'
  states: {}
- name: total_num
  id: qtgui_number_sink
  parameters:
    name: '"Total level (dBFS)"'
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '-100'
    max: '0'
    unit1: dB
  states: {}
- name: spec
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Spectrum at the receiver output"'
    fftsize: '4096'
    fc: '0'
    bw: samp_rate
    grid: 'True'
    average: '0.05'
    ymax: '0'
    ctrlpanel: 'True'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '800000000'
  states: {}
- name: freq_error_hz
  id: variable
  parameters:
    value: '0'
  states: {}
- name: pluto_source
  id: iio_pluto_source
  parameters:
    type: fc32
    frequency: center_freq
    samplerate: samp_rate
    buffer_size: '32768'
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    gain1: '''manual'''
    manual_gain1: gain
    filter_source: '''Auto'''
    bandwidth: '1500000'
  states: {}
- name: fine_rotator
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*math.pi*freq_error_hz/samp_rate'
  states: {}

connections:
- [fine_rotator, '0', noise_band, '0']
- [noise_band, '0', noise_rms, '0']
- [noise_rms, '0', noise_db, '0']
- [noise_db, '0', noise_num, '0']
- [fine_rotator, '0', t1_band, '0']
- [t1_band, '0', t1_rms, '0']
- [t1_rms, '0', t1_db, '0']
- [t1_db, '0', tone_num, '0']
- [fine_rotator, '0', t2_band, '0']
- [t2_band, '0', t2_rms, '0']
- [t2_rms, '0', t2_db, '0']
- [t2_db, '0', tone_num, '1']
- [fine_rotator, '0', im_lo_band, '0']
- [im_lo_band, '0', im_lo_rms, '0']
- [im_lo_rms, '0', im_lo_db, '0']
- [im_lo_db, '0', tone_num, '2']
- [fine_rotator, '0', im_hi_band, '0']
- [im_hi_band, '0', im_hi_rms, '0']
- [im_hi_rms, '0', im_hi_db, '0']
- [im_hi_db, '0', tone_num, '3']
- [fine_rotator, '0', total_rms, '0']
- [total_rms, '0', total_log, '0']
- [total_log, '0', total_num, '0']
- [fine_rotator, '0', spec, '0']
- [pluto_source, '0', fine_rotator, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
